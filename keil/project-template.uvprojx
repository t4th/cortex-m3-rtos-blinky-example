# Keil uVision project project-template.uvprojx, settings and files
target stm32f103ze (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project-template
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=3
  c misc: -fno-exceptions
  c include: ..\external\arm;..\external\st\STM32F10x;..\rtos\source;..\rtos\source\config;..\rtos\source\hardware;..\rtos\source\common;..\rtos\source\event;..\rtos\source\handle;..\rtos\source\lock;..\rtos\source\system_timer;..\rtos\source\task;..\rtos\source\timer;..\rtos\source\scheduler
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ../source/main/: main.cpp
  group rtos
    ../rtos/source/: kernel.cpp
  group armv7-m
    ../rtos/source/hardware/armv7m/: hardware.cpp
  group external
    ../rtos/external/st/STM32F10x/: startup_stm32f10x_hd.s system_stm32f10x.c
